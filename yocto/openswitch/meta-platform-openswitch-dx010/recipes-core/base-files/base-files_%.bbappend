# Copyright (C) 2015 Hewlett Packard Enterprise Development LP

PR_append = "_dx010"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
