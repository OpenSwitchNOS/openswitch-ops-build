# Copyright (C) 2015 Hewlett Packard Enterprise Development LP

PR_append = "_as5812x"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
