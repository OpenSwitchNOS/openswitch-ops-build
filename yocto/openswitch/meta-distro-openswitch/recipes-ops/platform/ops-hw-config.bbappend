SRC_URI = "git://git.openswitch.net/openswitch/ops-hw-config;protocol=http;branch=feature/qos \
"

SRCREV = "${AUTOREV}"
