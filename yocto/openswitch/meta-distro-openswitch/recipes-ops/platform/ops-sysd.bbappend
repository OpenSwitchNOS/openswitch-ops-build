SRC_URI = "git://git.openswitch.net/openswitch/ops-sysd;protocol=https;branch=feature/qos \
           file://ops-sysd.service \
           "

SRCREV = "${AUTOREV}"
