# Recipe variable overrides for feature/acl branch

SRC_URI = "git://git.openswitch.net/openswitch/ops;protocol=https"

SRCREV = "1dd6849fda2fb284af2e21015257770e1ca9bc26"
