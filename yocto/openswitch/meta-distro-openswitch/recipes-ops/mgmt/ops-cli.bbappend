# Recipe variable overrides for feature/acl branch

SRC_URI = "git://git.openswitch.net/openswitch/ops-cli;protocol=http;branch=feature/acl \
"

SRCREV = "422a535528550bcc7786a80bb7bc6be961e8197b"
