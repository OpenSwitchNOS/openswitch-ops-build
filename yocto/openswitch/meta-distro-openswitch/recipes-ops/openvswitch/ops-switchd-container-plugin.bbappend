OPS_REPO_BRANCH = "feature/acl"

SRCREV = "${AUTOREV}"
