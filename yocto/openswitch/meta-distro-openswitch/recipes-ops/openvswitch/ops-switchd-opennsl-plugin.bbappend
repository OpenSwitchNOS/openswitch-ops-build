# Recipe variable overrides for feature/acl branch

SRC_URI = "git://git.openswitch.net/openswitch/ops-switchd-opennsl-plugin;protocol=http;branch=feature/acl"

SRCREV = "b08a4257b4336dabcee68c6f2db6045337c40225"
