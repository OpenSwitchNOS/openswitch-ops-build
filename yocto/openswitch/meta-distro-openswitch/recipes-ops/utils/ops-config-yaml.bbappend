SRC_URI = "git://git.openswitch.net/openswitch/ops-config-yaml;protocol=https;branch=feature/qos"

SRCREV = "${AUTOREV}"
