SRC_URI = "git://git.openswitch.net/openswitch/ops-intfd;protocol=http;branch=feature/qos \
           file://ops-intfd.service"

SRCREV = "${AUTOREV}"
