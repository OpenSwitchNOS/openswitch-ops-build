require python-jsonschema.inc

RDEPENDS_${PN} = "\
    python-core \
"

BBCLASSEXTEND = "native"
