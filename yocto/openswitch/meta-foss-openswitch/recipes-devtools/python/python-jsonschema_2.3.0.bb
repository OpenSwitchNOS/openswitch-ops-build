require python-jsonschema.inc

RDEPENDS_${PN} = "\
    python-core \
    python-io \
    python-json \
    python-math \
    python-textutils \
    python-misc \
    python-tests \
    python-shell \
    python-numbers \
    python-lang \
    python-pkgutil \
    python-re \
    python-subprocess \
    python-pprint \
    python-contextlib \
"
