# Copyright Mellanox Technologies, Ltd. 2001-2016.
# This software product is licensed under Apache version 2, as detailed in
# the COPYING file.

EXTRA_OECMAKE+="-DUSE_SW_FRU=ON -DPLATFORM_SIMULATION=ON"
